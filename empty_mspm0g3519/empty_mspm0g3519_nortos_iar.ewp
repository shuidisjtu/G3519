# IAR project empty_mspm0g3519_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3519 TexasInstruments MSPM0G3519
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3519__
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; C:\ti\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include; C:\ti\mspm0_sdk_2_10_00_04\source
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$
  ILINK.IlinkOutputFile: empty_mspm0g3519_nortos_iar.out
  ILINK.IlinkIcfFile: mspm0g3519.icf
  ILINK.IlinkExtraOptions: C:\ti\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\iar\m0p\mspm0gx51x\driverlib.a; --silent
  group (top)
    ./: SysConfig_Generated_Files.ipcf
  group empty_mspm0g3519
    ./: empty_mspm0g3519.c empty_mspm0g3519.syscfg mspm0g3519.icf README.md
  group empty_mspm0g3519/iar
    iar/: startup_mspm0g351x_iar.c
  group SysConfig Generated Files
    ./: ti_msp_dl_config.c ti_msp_dl_config.h
