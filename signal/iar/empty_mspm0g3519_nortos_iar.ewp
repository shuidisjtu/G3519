# IAR project empty_mspm0g3519_nortos_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSPM0G3519 TexasInstruments MSPM0G3519
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __MSPM0G3519__; ARM_MATH_CM0
  ICCARM.IExtraOptions: --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/Core/Include; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/DSP/Include; $MSPM0_SDK_INSTALL_DIR$/source; ..\..\common\NUEDC2025; ..\..\common\TSP3519; ..\..\common\drivers; ..\app
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: $PROJ_DIR$; ..\..\common\TSP3519; ..\..\common\NUEDC2025
  ILINK.IlinkOutputFile: empty_mspm0g3519_nortos_iar.out
  ILINK.IlinkIcfFile: mspm0g3519.icf
  ILINK.IlinkExtraOptions: $MSPM0_SDK_INSTALL_DIR$/source/ti/driverlib/lib/iar/m0p/mspm0gx51x/driverlib.a; $MSPM0_SDK_INSTALL_DIR$/source/third_party/CMSIS/DSP/lib/iar/m0p/arm_cortexM0l_math.a; --silent
  group (top)
    ./: SysConfig_Generated_Files.ipcf
  group empty_mspm0g3519
    ./: empty_mspm0g3519.c empty_mspm0g3519.syscfg mspm0g3519.icf
  group empty_mspm0g3519/iar
    iar/: startup_mspm0g351x_iar.c
  group NUEDC2025
    ../../common/NUEDC2025/: tsp_encoder.c tsp_encoder.h tsp_isr.c tsp_isr.h tsp_key.c tsp_key.h tsp_uart.c tsp_uart.h tsp_uart_k230.c tsp_uart_k230.h
    ../../common/drivers/: tsp_ad5933.c tsp_ad5933.h tsp_dds.c tsp_dds.h tsp_adc.c tsp_adc.h tsp_uart3.c tsp_uart3.h
    ../app/: tsp_mcp41010.c tsp_mcp41010.h tsp_cmd.c tsp_cmd.h tsp_fft.c tsp_fft.h tsp_scope.c tsp_scope.h tsp_tjc.c tsp_tjc.h
  group SysConfig Generated Files
    ./: Event.dot ti_msp_dl_config.c ti_msp_dl_config.h
  group TSP3519
    ../../common/TSP3519/: tsp_gpio.c tsp_gpio.h tsp_menu.c tsp_menu.h TSP_TFT18.c TSP_TFT18.h
